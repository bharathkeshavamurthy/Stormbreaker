<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>76</value></param>
<param><key>comment</key><value>Acceptable range is 0 to 76 in 1 dB increments</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5.2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/home/mlanoue/Documents/Anderson_Test/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_now</value></param>
<param><key>value</key><value>datetime.now().strftime("%Y.%m.%d.%H.%M.%S")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logfile</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + "_log.txt"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"/mnt/ram/"</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>144.39e6</value></param>
<param><key>min</key><value>144e6</value></param>
<param><key>max</key><value>145e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import delayed_start</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1_1</value></param>
<param><key>import</key><value>import gpsdo</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>gpsdo_test</value></param>
<param><key>deps</key><value>{}</value></param>
<param><key>code</key><value>gpsdo.gpsdo(self.uhd_usrp_source_0)</value></param>
<param><key>value</key><value>None</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>callback_mode</key><value>inline</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>"master_clock_rate=52e6, --fifo=self.logfile"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>2</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>99.9e6</value></param>
<param><key>min</key><value>89e6</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>num_steps</key><value>190</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>current_time</value></param>
<param><key>deps</key><value>{}</value></param>
<param><key>code</key><value>delayed_start.main(self.uhd_usrp_source_0)</value></param>
<param><key>value</key><value>None</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>callback_mode</key><value>inline</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>delayed_starter</value></param>
<param><key>deps</key><value>{}</value></param>
<param><key>code</key><value>delayed_start.delayed_start(self.uhd_usrp_source_0, delay=2, pps=False, base_time=None, offset=0, gpsdo=True)</value></param>
<param><key>value</key><value>None</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>callback_mode</key><value>inline</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>gpsdo_logfile</value></param>
<param><key>deps</key><value>{}</value></param>
<param><key>code</key><value>gpsdo.main(self.uhd_usrp_source_0, self.rx_gain, self.logfile)</value></param>
<param><key>value</key><value>None</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>callback_mode</key><value>inline</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
