options:
  parameters:
    generate_options: qt_gui
    id: Sliding_Correlator_Channel_Sounder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    alias: File_Sink
    append: 'True'
    file: /home/pi/Workspaces/odin/sounder/logs/power_delay_profiles.log
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alias: QT_GUI_Time_Sink
    grid: 'True'
    name: '"QT_GUI_Time_Sink"'
    size: '1024'
    srate: 200e3
    type: complex
    update_time: '1'
    ymax: '0.1'
    ymin: '0.0'
    yunit: ''
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    alias: UHD_USRP_Source
    ant0: TX/RX
    center_freq0: 2.5e9
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: 200e3
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
